# Keil uVision project B02A11-H1.uvprojx, settings and files
target B02A11-H1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: B02A11-H1 +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32G431xx
  c include: ../Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../MCSDK_v5.4.5-Full/MotorControl/MCSDK/MCLib/Any/Inc;../MCSDK_v5.4.5-Full/MotorControl/MCSDK/MCLib/G4xx/Inc;../MCSDK_v5.4.5-Full/MotorControl/MCSDK/UILibrary/Inc;../MCSDK_v5.4.5-Full/MotorControl/MCSDK/SystemDriveParams;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;..\I2C;..\Agreement;..\PID;..\CANopen;..\BLDC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: main.c mc_api.c motorcontrol.c motor_control_protocol.c mc_config.c mc_tasks.c regular_conversion_manager.c mc_math.c mc_interface.c stm32g4xx_mc_it.c mc_parameters.c ui_task.c user_interface.c dac_ui.c stm32g4xx_it.c stm32g4xx_hal_msp.c
    ../I2C/: stspin32g4.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_cordic.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_opamp.c stm32g4xx_hal_comp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_fdcan.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Middlewares/MotorControl
    ../MCSDK_v5.4.5-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c enc_align_ctrl.c encoder_speed_pos_fdbk.c flux_weakening_ctrl.c hall_speed_pos_fdbk.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_curr_fdbk.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_speed_sensor.c
    ../MCSDK_v5.4.5-Full/MotorControl/MCSDK/MCLib/G4xx/Src/: r3_2_g4xx_pwm_curr_fdbk.c
    ../MCSDK_v5.4.5-Full/MotorControl/MCSDK/UILibrary/Src/: dac_common_ui.c frame_communication_protocol.c ui_irq_handler.c usart_frame_communication_protocol.c
  group BLDC
    ../BLDC/: bsp_BDCMotor.c function.c Sensorless bldc.c
  group Agreement
    ../Agreement/: Agreement.c flash.c
  group CANopen
    ../PID/: pid.c
    ../CANopen/: bsp_CAN.c canopen_emcy.c canopen_lifegrd.c canopen_nmt.c canopen_objacces.c canopen_od.c canopen_pdo.c canopen_sdo.c canopen_sync.c canopen_timer.c
  group Readme
    ../: Readme.txt
software components: CMSIS:CORE 5.1.2
